# Keil uVision project LAB2.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LAB2 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HSE_VALUE=8000000, STM32F407xx, ARM_MATH_CM4, __FPU_PRESENT = 1, USE_HAL_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c Assembly.s fput_debug.c
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6, Device:STM32Cube Framework:STM32CubeMX 1.0.0, Device:STM32Cube HAL:ADC 1.4.2, Device:STM32Cube HAL:Cortex 1.4.2, Device:STM32Cube HAL:DAC 1.4.2, Device:STM32Cube HAL:Flash 1.4.2, Device:STM32Cube HAL:GPIO 1.4.2, Device:Startup 2.4.2
